# Keil uVision project ISP_UART.uvproj, settings and files
target ISP_UART (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: ISP_UART +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\M480\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\uart_iap.sct
  group CMSIS
    ../../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group User
    ../: main.c fmc_user.c isp_user.c targetdev.c uart_transfer.c
  group Library
    ../../../../Library/StdDriver/src/: fmc.c clk.c retarget.c uart.c sys.c timer.c gpio.c crc.c rtc.c
